<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NsfDetect10rtlsdr</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>Rtlsdr 1st try</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Nsf Astronomical Event Detect: 1MHz </value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Azimuth</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Azimuth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>6.e6</value></param>
<param><key>gui_hint</key><value>1,6,1,1</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Device</value></param>
<param><key>value</key><value>airspy,bias=1,pack=1</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>label</key><value>Dev</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Elevation</value></param>
<param><key>value</key><value>-90</value></param>
<param><key>gui_hint</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Elevation</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>EventMode</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5, 0,2, 2</value></param>
<param><key>label0</key><value>Wait</value></param>
<param><key>label1</key><value>Write</value></param>
<param><key>label</key><value>Event Mode</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>1420.4e6</value></param>
<param><key>gui_hint</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Freq. Hz</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Gain1</value></param>
<param><key>value</key><value>14.0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Gain1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Mode</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>7,0,2,2</value></param>
<param><key>label0</key><value>Monitor</value></param>
<param><key>label1</key><value>Detect</value></param>
<param><key>label</key><value>Mode</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Telescope</value></param>
<param><key>value</key><value>telescope_save</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>Tel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>2048</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Window_size</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nsigma</value></param>
<param><key>value</key><value>4.0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>N Sigma</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>10.</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>observer</value></param>
<param><key>value</key><value>observers_save</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Who</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,3,10,5</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>size</key><value>fftsize</value></param>
<param><key>srate</key><value>Bandwidth</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Event</value></param>
<param><key>ymax</key><value>.3</value></param>
<param><key>ymin</key><value>-.3</value></param>
</block>
<block>
<key>ra_event_log</key>
<param><key>id</key><value>ra_event_log_0</value></param>
<param><key>logname</key><value></value></param>
<param><key>note</key><value>First Airspy Overnight event test</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.E-6</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>ra_event_sink</key>
<param><key>id</key><value>ra_event_sink_0</value></param>
<param><key>record</key><value>EventMode</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.E-6</value></param>
<param><key>setup</key><value>Watch.not</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>radio_astro_detect</key>
<param><key>id</key><value>radio_astro_detect_0</value></param>
<param><key>mode</key><value>Mode</value></param>
<param><key>dms</key><value>nsigma</value></param>
<param><key>bw</key><value>Bandwidth*1.e-6</value></param>
<param><key>f_obs</key><value>Frequency*1.E-6</value></param>
<param><key>t_int</key><value>fftsize*1.e-6/Bandwidth</value></param>
<param><key>vec_length</key><value>fftsize</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>12</value></param>
<param><key>bw0</key><value>Bandwidth</value></param>
<param><key>freq0</key><value>Frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>12</value></param>
<param><key>gain0</key><value>Gain1</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>args</key><value>Device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>Bandwidth</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>radio_astro_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>ra_event_log_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>ra_event_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
